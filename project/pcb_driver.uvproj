# Keil uVision project pcb_driver.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ADuC7122 Analog Devices
  cpu: IRAM(0x40000-0x41FFF) IROM(0x80000-0x9F7FF) CLOCK(41780000) CPUTYPE(ARM7TDMI)
  output: mems_mcu +hex
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x80000 size 0x1f800
  memory RVCT9: RAM 0x40000 size 0x2000
  group Source Group 1
    ./: ADuC7122.s
    ../global/: irq_arm.c global.c
    ../application/: main.c scan.c calibration.c um.c
    ../system/: dds.c pga_1ch.c pga_4ch.c
    ../peripheral/: adc.c dac.c flash.c uart.c wire3.c
